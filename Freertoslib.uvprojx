# Keil uVision project Freertoslib.uvprojx, settings and files
target Freertoslib (ARM-ADS)
  device: MKL17Z128xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.4.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x1FFFE000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Freertoslib (library)
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\rtos\FreeRTOS\config\KL43Z4\keil;.\rtos\FreeRTOS\include;.\rtos\FreeRTOS\port\keil
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  group freertos
    ./rtos/FreeRTOS/port/keil/: port.c
    ./rtos/FreeRTOS/src/: croutine.c event_groups.c heap_2.c list.c queue.c tasks.c timers.c
