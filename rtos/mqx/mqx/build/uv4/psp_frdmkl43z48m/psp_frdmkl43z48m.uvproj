# Keil uVision project psp_frdmkl43z48m.uvproj, settings and files
target psp_frdmkl43z48m Debug (ARM-ADS)
  device: MKL43Z256xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.2.2
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x6000) IRAM2(0x1FFFE000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(48000000) ELITTLE
  output: psp.lib (library)
  AfterMake: ../../bat/psp_frdmkl43z48m.bat ../../../.. ../../../../lib/frdmkl43z48m.uv4/debug/psp uv4
  c flags: Optim=1 OneElfS=1
  c define: CPU_MKL43Z256VLH4=1, FSL_RTOS_MQX=1, MQX_DISABLE_CONFIG_CHECK=1, _DEBUG=1
  c misc: -J../../../source/psp/cortex_m/compiler/rv_uv4 
-J../../../../../../platform/CMSIS/Include/device 
-J../../../../../../platform/CMSIS/Include 
-J../../../source/psp/cortex_m 
-J../../../source/psp/cortex_m/cpu 
-J../../../../config/mcu/mkl43z256 
-J../../../../config/board/frdmkl43z48m 
-J../../../../config/common 
-J../../../source/include 
-J../../../source/nio 
-J../../../source/nio/src 
-J../../../source/nio/fs 
-J../../../source/tad 
-J../../../../config/mcu/mkl43z256 
-J../../../../config/board/frdmkl43z48m 
-J../../../../config/common 
-J../../../source/bsp/KL43Z4 
-J../../../source/include 
-J../../../source/bsp 
-J../../../source/nio/drivers/nio_dummy 
-J../../../source/nio/drivers/nio_mem 
-J../../../source/nio/drivers/nio_null 
-J../../../source/nio/drivers/nio_pipe 
-J../../../source/nio/drivers/nio_serial 
-J../../../source/nio/drivers/nio_tfs 
-J../../../source/nio/drivers/nio_tty 
-J../../../../../../boards/frdmkl43z48m 
-J../../../../../../platform/startup/MKL43Z4 
-J../../../../mqx_stdlib/source/include 
-J../../../../mqx_stdlib/source/stdio 
-J../../../../../../platform 
-J../../../../../../platform/CMSIS/Include 
-J../../../../../../platform/CMSIS/Include/device 
-J../../../../../../platform/hal/adc 
-J../../../../../../platform/hal/can 
-J../../../../../../platform/hal/dac 
-J../../../../../../platform/hal/dma 
-J../../../../../../platform/hal/dmamux 
-J../../../../../../platform/hal/dspi 
-J../../../../../../platform/hal/edma 
-J../../../../../../platform/hal/enet 
-J../../../../../../platform/hal/flextimer 
-J../../../../../../platform/hal/gpio 
-J../../../../../../platform/hal/i2c 
-J../../../../../../platform/hal/llwu 
-J../../../../../../platform/hal/lptmr 
-J../../../../../../platform/hal/lpuart 
-J../../../../../../platform/hal/mcg 
-J../../../../../../platform/hal/mpu 
-J../../../../../../platform/hal/osc 
-J../../../../../../platform/hal/pdb 
-J../../../../../../platform/hal/pit 
-J../../../../../../platform/hal/pmc 
-J../../../../../../platform/hal/port 
-J../../../../../../platform/hal/rcm 
-J../../../../../../platform/hal/rtc 
-J../../../../../../platform/hal/sai 
-J../../../../../../platform/hal/sdhc 
-J../../../../../../platform/hal/sim 
-J../../../../../../platform/hal/smc 
-J../../../../../../platform/hal/spi 
-J../../../../../../platform/hal/uart 
-J../../../../../../platform/hal/wdog 
-J../../../../../../platform/drivers/adc 
-J../../../../../../platform/drivers/adc/common 
-J../../../../../../platform/drivers/can 
-J../../../../../../platform/drivers/can/common 
-J../../../../../../platform/drivers/cmp 
-J../../../../../../platform/drivers/cmp/common 
-J../../../../../../platform/drivers/dac 
-J../../../../../../platform/drivers/dac/common 
-J../../../../../../platform/drivers/dma 
-J../../../../../../platform/drivers/dma/common 
-J../../../../../../platform/drivers/dspi/dspi_master 
-J../../../../../../platform/drivers/dspi/dspi_slave 
-J../../../../../../platform/drivers/dspi/common 
-J../../../../../../platform/drivers/edma 
-J../../../../../../platform/drivers/edma/common 
-J../../../../../../platform/drivers/enet 
-J../../../../../../platform/drivers/enet/common 
-J../../../../../../platform/drivers/flash 
-J../../../../../../platform/drivers/flextimer 
-J../../../../../../platform/drivers/flextimer/common 
-J../../../../../../platform/drivers/gpio 
-J../../../../../../platform/drivers/gpio/common 
-J../../../../../../platform/drivers/i2c/i2c_master 
-J../../../../../../platform/drivers/i2c/i2c_slave 
-J../../../../../../platform/drivers/i2c/common 
-J../../../../../../platform/drivers/lptmr 
-J../../../../../../platform/drivers/lptmr/common 
-J../../../../../../platform/drivers/lpuart 
-J../../../../../../platform/drivers/lpuart/common 
-J../../../../../../platform/drivers/mmcau 
-J../../../../../../platform/drivers/mpu 
-J../../../../../../platform/drivers/mpu/common 
-J../../../../../../platform/drivers/pdb 
-J../../../../../../platform/drivers/pdb/common 
-J../../../../../../platform/drivers/pit 
-J../../../../../../platform/drivers/pit/common 
-J../../../../../../platform/drivers/rnga 
-J../../../../../../platform/drivers/rnga/common 
-J../../../../../../platform/drivers/rtc 
-J../../../../../../platform/drivers/rtc/common 
-J../../../../../../platform/drivers/sai 
-J../../../../../../platform/drivers/sai/common 
-J../../../../../../platform/drivers/sdcard 
-J../../../../../../platform/drivers/sdhc 
-J../../../../../../platform/drivers/sdhc/common 
-J../../../../../../platform/drivers/soundcard 
-J../../../../../../platform/drivers/spi 
-J../../../../../../platform/drivers/spi/common 
-J../../../../../../platform/drivers/uart 
-J../../../../../../platform/drivers/uart/common 
-J../../../../../../platform/drivers/wdog 
-J../../../../../../platform/drivers/wdog/common 
-J../../../../../../platform/utilities 
-J../../../../../../rtos 
-J../../../../../../platform/osa 
-J../../../../../../platform/system/interrupt 
-J../../../../../../platform/system/clock 
-J../../../../../../platform/system/hwtimer 
-J#J 
--library_interface=none 
--library_type=standardlib 
--c99 
--diag_suppress=1296,186
  c include: ../../../source/psp/cortex_m/compiler/rv_uv4;../../../../../../platform/CMSIS/Include/device;../../../../../../platform/CMSIS/Include;../../../source/psp/cortex_m;../../../source/psp/cortex_m/cpu;../../../../config/mcu/mkl43z256;../../../../config/board/frdmkl43z48m;../../../../config/common;../../../source/include;../../../source/nio;../../../source/nio/src;../../../source/nio/fs;../../../source/tad;../../../../config/mcu/mkl43z256;../../../../config/board/frdmkl43z48m;../../../../config/common;../../../source/bsp/KL43Z4;../../../source/include;../../../source/bsp;../../../source/nio/drivers/nio_dummy;../../../source/nio/drivers/nio_mem;../../../source/nio/drivers/nio_null;../../../source/nio/drivers/nio_pipe;../../../source/nio/drivers/nio_serial;../../../source/nio/drivers/nio_tfs;../../../source/nio/drivers/nio_tty;../../../../../../boards/frdmkl43z48m;../../../../../../platform/startup/MKL43Z4;../../../../mqx_stdlib/source/include;../../../../mqx_stdlib/source/stdio;../../../../../../platform;../../../../../../platform/CMSIS/Include;../../../../../../platform/CMSIS/Include/device;../../../../../../platform/hal/adc;../../../../../../platform/hal/can;../../../../../../platform/hal/dac;../../../../../../platform/hal/dma;../../../../../../platform/hal/dmamux;../../../../../../platform/hal/dspi;../../../../../../platform/hal/edma;../../../../../../platform/hal/enet;../../../../../../platform/hal/flextimer;../../../../../../platform/hal/gpio;../../../../../../platform/hal/i2c;../../../../../../platform/hal/llwu;../../../../../../platform/hal/lptmr;../../../../../../platform/hal/lpuart;../../../../../../platform/hal/mcg;../../../../../../platform/hal/mpu;../../../../../../platform/hal/osc;../../../../../../platform/hal/pdb;../../../../../../platform/hal/pit;../../../../../../platform/hal/pmc;../../../../../../platform/hal/port;../../../../../../platform/hal/rcm;../../../../../../platform/hal/rtc;../../../../../../platform/hal/sai;../../../../../../platform/hal/sdhc;../../../../../../platform/hal/sim;../../../../../../platform/hal/smc;../../../../../../platform/hal/spi;../../../../../../platform/hal/uart;../../../../../../platform/hal/wdog;../../../../../../platform/drivers/adc;../../../../../../platform/drivers/adc/common;../../../../../../platform/drivers/can;../../../../../../platform/drivers/can/common;../../../../../../platform/drivers/cmp;../../../../../../platform/drivers/cmp/common;../../../../../../platform/drivers/dac;../../../../../../platform/drivers/dac/common;../../../../../../platform/drivers/dma;../../../../../../platform/drivers/dma/common;../../../../../../platform/drivers/dspi/dspi_master;../../../../../../platform/drivers/dspi/dspi_slave;../../../../../../platform/drivers/dspi/common;../../../../../../platform/drivers/edma;../../../../../../platform/drivers/edma/common;../../../../../../platform/drivers/enet;../../../../../../platform/drivers/enet/common;../../../../../../platform/drivers/flash;../../../../../../platform/drivers/flextimer;../../../../../../platform/drivers/flextimer/common;../../../../../../platform/drivers/gpio;../../../../../../platform/drivers/gpio/common;../../../../../../platform/drivers/i2c/i2c_master;../../../../../../platform/drivers/i2c/i2c_slave;../../../../../../platform/drivers/i2c/common;../../../../../../platform/drivers/lptmr;../../../../../../platform/drivers/lptmr/common;../../../../../../platform/drivers/lpuart;../../../../../../platform/drivers/lpuart/common;../../../../../../platform/drivers/mmcau;../../../../../../platform/drivers/mpu;../../../../../../platform/drivers/mpu/common;../../../../../../platform/drivers/pdb;../../../../../../platform/drivers/pdb/common;../../../../../../platform/drivers/pit;../../../../../../platform/drivers/pit/common;../../../../../../platform/drivers/rnga;../../../../../../platform/drivers/rnga/common;../../../../../../platform/drivers/rtc;../../../../../../platform/drivers/rtc/common;../../../../../../platform/drivers/sai;../../../../../../platform/drivers/sai/common;../../../../../../platform/drivers/sdcard;../../../../../../platform/drivers/sdhc;../../../../../../platform/drivers/sdhc/common;../../../../../../platform/drivers/soundcard;../../../../../../platform/drivers/spi;../../../../../../platform/drivers/spi/common;../../../../../../platform/drivers/uart;../../../../../../platform/drivers/uart/common;../../../../../../platform/drivers/wdog;../../../../../../platform/drivers/wdog/common;../../../../../../platform/utilities;../../../../../../rtos;../../../../../../platform/osa;../../../../../../platform/system/interrupt;../../../../../../platform/system/clock;../../../../../../platform/system/hwtimer
  asm define: as above
  asm misc: --cpreproc
  asm include: ../../../source/psp/cortex_m/compiler/rv_uv4;../../../source/psp/cortex_m;../../../source/psp/cortex_m/core/M0;../../../../config/frdmkl43z48m;../../../source/include;../../../../config/common;../../../../config/mcu/mkl43z256;../../../../config/board/frdmkl43z48m
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: ..\..\..\lib\frdmkl43z48m.uv4\mqx\intflash.scf
  group PSP Generic/include
    ../../../source/psp/cortex_m/compiler/rv_uv4/: asm_mac.h comp.h comp.c linker_symbols.S
    ../../../source/include/: gen_rev.h eds.h edserial.h edserprv.h eds_prv.h event.h event_prv.h charq.h klog.h log.h log_prv.h lwsem.h lwevent.h lwevent_prv.h lwlog.h lwlog_prv.h lwmem.h lwmem_prv.h lwmsgq.h lwmsgq_prv.h lwtimer.h lwtimer_prv.h mem_prv.h message.h mmu.h mqx.h mqx_cnfg.h mqx_cpudef.h mqx_inc.h mqx_ioc.h mqx_prv.h mqx_str.h mqx_macros.h msg_prv.h mutex.h mutex_prv.h name.h name_prv.h partition.h partition_prv.h pcb.h posix.h queue.h sem.h sem_prv.h timer.h timer_prv.h watchdog.h watchdog_prv.h unicode.h
  group PSP Specific
    ../../../../../../platform/CMSIS/Include/device/: fsl_device_registers.h
    ../../../../../../platform/CMSIS/Include/: core_cm0plus.h core_cmFunc.h core_cmInstr.h
    ../../../source/psp/cortex_m/: types.inc int_gkis.c int_inst.c int_kisr.c int_pvta.c int_unx.c int_vtab.c int_xcpt.c ipsum.c mem_copy.c mem_zero.c psp_dati.c psp_gelms.c psp_hoti.c psp_iinit.c psp_mat1.c psp_mat2.c psp_mat3.c psp_miti.c psp_msti.c psp_mstiq.c psp_nsti.c psp_psti.c psp_seti.c psp_supp.c psp_tiad.c psp_tida.c psp_tihr.c psp_timn.c psp_tims.c psp_tinm.c psp_tins.c psp_tiol.c psp_tipr.c psp_tips.c psp_tise.c psp_tisu.c psp_tius.c psp_tkti.c psp_usti.c sc_irdyq.c stack_bu.c stack_de.c stack_st.c psp.h psp_abi.h psp_comp.h psp_math.h psp_prv.h psp_rev.h psp_supp.h psp_time.h psptypes.h psp_cpu.h psp_cpudef.h cortex.h kinetis_mpu.h cortex.c nvic.c nvic.h kinetis.h
    ../../../source/psp/cortex_m/core/M0/: psp_prv.inc boot.S dispatch.S
    ../../../source/psp/cortex_m/cpu/: kinetis_fcan.h
  group Config Files
    ../../../../config/mcu/mkl43z256/: mqx_sdk_config.h
    ../../../../config/board/frdmkl43z48m/: user_config.h
    ../../../../config/common/: small_ram_config.h
  group PSP Generic/kernel
    ../../../source/kernel/: event.c idletask.c inittask.c int.c lwsem.c mem.c mqx.c sched.c task.c time.c taskq.c klog.c log.c lwevent.c lwlog.c lwmem.c lwmsgq.c lwtimer.c msg.c msgq.c msgpool.c mutex.c name.c partition.c queue.c sem.c timer.c watchdog.c
  group PSP Generic/nio
    ../../../source/nio/src/: nio.c nio_prv.h errno.c
    ../../../source/nio/: nio.h errno.h ioctl.h fcntl.h
    ../../../source/nio/fs/: fs_supp.c fs_supp.h
  group PSP Generic/string
    ../../../source/string/: strnlen.c str_utos.c unicode.c
  group PSP Generic/tad
    ../../../source/tad/: tad.c tad.h
target psp_frdmkl43z48m Release (ARM-ADS)
  device: MKL43Z256xxx4 Freescale Semiconductor
  pack: Keil.Kinetis_KLxx_DFP.1.2.2
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x6000) IRAM2(0x1FFFE000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(48000000) ELITTLE
  output: psp.lib (library)
  AfterMake: ../../bat/psp_frdmkl43z48m.bat ../../../.. ../../../../lib/frdmkl43z48m.uv4/release/psp uv4
  c flags: Optim=4 OneElfS=1
  c define: CPU_MKL43Z256VLH4=1, FSL_RTOS_MQX=1, MQX_DISABLE_CONFIG_CHECK=1, NDEBUG=1
  c misc: as above
  c include: as above
  asm define: as above
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: ..\..\..\lib\frdmkl43z48m.uv4\mqx\intflash.scf
