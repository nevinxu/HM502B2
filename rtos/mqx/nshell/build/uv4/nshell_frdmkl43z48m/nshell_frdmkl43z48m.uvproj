# Keil uVision project nshell_frdmkl43z48m.uvproj, settings and files
target nshell_frdmkl43z48m Debug (ARM-ADS)
  device: MKL43Z256xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.2.2
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x6000) IRAM2(0x1FFFE000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(48000000) ELITTLE
  output: nshell.lib (library)
  AfterMake: ../../bat/nshell_frdmkl43z48m.bat ../../../.. ../../../../lib/frdmkl43z48m.uv4/debug/nshell uv4
  c flags: Optim=1 OneElfS=1
  c define: CPU_MKL43Z256VLH4=1, FSL_RTOS_MQX=1, _DEBUG=1
  c misc: -J../../../source/include 
-J../../../source/include 
-J../../../../config/mcu/mkl43z256 
-J../../../../config/board/frdmkl43z48m 
-J../../../../config/common 
-J../../../../mqx/source/bsp/KL43Z4 
-J../../../../mqx/source/include 
-J../../../../mqx/source/bsp 
-J../../../../mqx/source/nio/drivers/nio_dummy 
-J../../../../mqx/source/nio/drivers/nio_mem 
-J../../../../mqx/source/nio/drivers/nio_null 
-J../../../../mqx/source/nio/drivers/nio_pipe 
-J../../../../mqx/source/nio/drivers/nio_serial 
-J../../../../mqx/source/nio/drivers/nio_tfs 
-J../../../../mqx/source/nio/drivers/nio_tty 
-J../../../../../../boards/frdmkl43z48m 
-J../../../../../../platform/startup/MKL43Z4 
-J../../../../mqx/source/psp/cortex_m/compiler/rv_uv4 
-J../../../../../../platform/CMSIS/Include/device 
-J../../../../../../platform/CMSIS/Include 
-J../../../../mqx/source/psp/cortex_m 
-J../../../../mqx/source/psp/cortex_m/cpu 
-J../../../../config/mcu/mkl43z256 
-J../../../../config/board/frdmkl43z48m 
-J../../../../config/common 
-J../../../../mqx/source/include 
-J../../../../mqx/source/nio 
-J../../../../mqx/source/nio/src 
-J../../../../mqx/source/nio/fs 
-J../../../../mqx/source/tad 
-J../../../../mqx_stdlib/source/include 
-J../../../../mqx_stdlib/source/stdio 
-J../../../../../../platform 
-J../../../../../../platform/CMSIS/Include 
-J../../../../../../platform/CMSIS/Include/device 
-J../../../../../../platform/hal/adc 
-J../../../../../../platform/hal/can 
-J../../../../../../platform/hal/dac 
-J../../../../../../platform/hal/dma 
-J../../../../../../platform/hal/dmamux 
-J../../../../../../platform/hal/dspi 
-J../../../../../../platform/hal/edma 
-J../../../../../../platform/hal/enet 
-J../../../../../../platform/hal/flextimer 
-J../../../../../../platform/hal/gpio 
-J../../../../../../platform/hal/i2c 
-J../../../../../../platform/hal/llwu 
-J../../../../../../platform/hal/lptmr 
-J../../../../../../platform/hal/lpuart 
-J../../../../../../platform/hal/mcg 
-J../../../../../../platform/hal/mpu 
-J../../../../../../platform/hal/osc 
-J../../../../../../platform/hal/pdb 
-J../../../../../../platform/hal/pit 
-J../../../../../../platform/hal/pmc 
-J../../../../../../platform/hal/port 
-J../../../../../../platform/hal/rcm 
-J../../../../../../platform/hal/rtc 
-J../../../../../../platform/hal/sai 
-J../../../../../../platform/hal/sdhc 
-J../../../../../../platform/hal/sim 
-J../../../../../../platform/hal/smc 
-J../../../../../../platform/hal/spi 
-J../../../../../../platform/hal/uart 
-J../../../../../../platform/hal/wdog 
-J../../../../../../platform/drivers/adc 
-J../../../../../../platform/drivers/adc/common 
-J../../../../../../platform/drivers/can 
-J../../../../../../platform/drivers/can/common 
-J../../../../../../platform/drivers/cmp 
-J../../../../../../platform/drivers/cmp/common 
-J../../../../../../platform/drivers/dac 
-J../../../../../../platform/drivers/dac/common 
-J../../../../../../platform/drivers/dma 
-J../../../../../../platform/drivers/dma/common 
-J../../../../../../platform/drivers/dspi/dspi_master 
-J../../../../../../platform/drivers/dspi/dspi_slave 
-J../../../../../../platform/drivers/dspi/common 
-J../../../../../../platform/drivers/edma 
-J../../../../../../platform/drivers/edma/common 
-J../../../../../../platform/drivers/enet 
-J../../../../../../platform/drivers/enet/common 
-J../../../../../../platform/drivers/flash 
-J../../../../../../platform/drivers/flextimer 
-J../../../../../../platform/drivers/flextimer/common 
-J../../../../../../platform/drivers/gpio 
-J../../../../../../platform/drivers/gpio/common 
-J../../../../../../platform/drivers/i2c/i2c_master 
-J../../../../../../platform/drivers/i2c/i2c_slave 
-J../../../../../../platform/drivers/i2c/common 
-J../../../../../../platform/drivers/lptmr 
-J../../../../../../platform/drivers/lptmr/common 
-J../../../../../../platform/drivers/lpuart 
-J../../../../../../platform/drivers/lpuart/common 
-J../../../../../../platform/drivers/mmcau 
-J../../../../../../platform/drivers/mpu 
-J../../../../../../platform/drivers/mpu/common 
-J../../../../../../platform/drivers/pdb 
-J../../../../../../platform/drivers/pdb/common 
-J../../../../../../platform/drivers/pit 
-J../../../../../../platform/drivers/pit/common 
-J../../../../../../platform/drivers/rnga 
-J../../../../../../platform/drivers/rnga/common 
-J../../../../../../platform/drivers/rtc 
-J../../../../../../platform/drivers/rtc/common 
-J../../../../../../platform/drivers/sai 
-J../../../../../../platform/drivers/sai/common 
-J../../../../../../platform/drivers/sdcard 
-J../../../../../../platform/drivers/sdhc 
-J../../../../../../platform/drivers/sdhc/common 
-J../../../../../../platform/drivers/soundcard 
-J../../../../../../platform/drivers/spi 
-J../../../../../../platform/drivers/spi/common 
-J../../../../../../platform/drivers/uart 
-J../../../../../../platform/drivers/uart/common 
-J../../../../../../platform/drivers/wdog 
-J../../../../../../platform/drivers/wdog/common 
-J../../../../../../platform/utilities 
-J../../../../../../rtos 
-J../../../../../../platform/osa 
-J../../../../../../platform/system/interrupt 
-J../../../../../../platform/system/clock 
-J../../../../../../platform/system/hwtimer 
-J#J 
--library_interface=none 
--library_type=standardlib 
--c99 
--diag_suppress=1296,186
  c include: ../../../source/include;../../../source/include;../../../../config/mcu/mkl43z256;../../../../config/board/frdmkl43z48m;../../../../config/common;../../../../mqx/source/bsp/KL43Z4;../../../../mqx/source/include;../../../../mqx/source/bsp;../../../../mqx/source/nio/drivers/nio_dummy;../../../../mqx/source/nio/drivers/nio_mem;../../../../mqx/source/nio/drivers/nio_null;../../../../mqx/source/nio/drivers/nio_pipe;../../../../mqx/source/nio/drivers/nio_serial;../../../../mqx/source/nio/drivers/nio_tfs;../../../../mqx/source/nio/drivers/nio_tty;../../../../../../boards/frdmkl43z48m;../../../../../../platform/startup/MKL43Z4;../../../../mqx/source/psp/cortex_m/compiler/rv_uv4;../../../../../../platform/CMSIS/Include/device;../../../../../../platform/CMSIS/Include;../../../../mqx/source/psp/cortex_m;../../../../mqx/source/psp/cortex_m/cpu;../../../../config/mcu/mkl43z256;../../../../config/board/frdmkl43z48m;../../../../config/common;../../../../mqx/source/include;../../../../mqx/source/nio;../../../../mqx/source/nio/src;../../../../mqx/source/nio/fs;../../../../mqx/source/tad;../../../../mqx_stdlib/source/include;../../../../mqx_stdlib/source/stdio;../../../../../../platform;../../../../../../platform/CMSIS/Include;../../../../../../platform/CMSIS/Include/device;../../../../../../platform/hal/adc;../../../../../../platform/hal/can;../../../../../../platform/hal/dac;../../../../../../platform/hal/dma;../../../../../../platform/hal/dmamux;../../../../../../platform/hal/dspi;../../../../../../platform/hal/edma;../../../../../../platform/hal/enet;../../../../../../platform/hal/flextimer;../../../../../../platform/hal/gpio;../../../../../../platform/hal/i2c;../../../../../../platform/hal/llwu;../../../../../../platform/hal/lptmr;../../../../../../platform/hal/lpuart;../../../../../../platform/hal/mcg;../../../../../../platform/hal/mpu;../../../../../../platform/hal/osc;../../../../../../platform/hal/pdb;../../../../../../platform/hal/pit;../../../../../../platform/hal/pmc;../../../../../../platform/hal/port;../../../../../../platform/hal/rcm;../../../../../../platform/hal/rtc;../../../../../../platform/hal/sai;../../../../../../platform/hal/sdhc;../../../../../../platform/hal/sim;../../../../../../platform/hal/smc;../../../../../../platform/hal/spi;../../../../../../platform/hal/uart;../../../../../../platform/hal/wdog;../../../../../../platform/drivers/adc;../../../../../../platform/drivers/adc/common;../../../../../../platform/drivers/can;../../../../../../platform/drivers/can/common;../../../../../../platform/drivers/cmp;../../../../../../platform/drivers/cmp/common;../../../../../../platform/drivers/dac;../../../../../../platform/drivers/dac/common;../../../../../../platform/drivers/dma;../../../../../../platform/drivers/dma/common;../../../../../../platform/drivers/dspi/dspi_master;../../../../../../platform/drivers/dspi/dspi_slave;../../../../../../platform/drivers/dspi/common;../../../../../../platform/drivers/edma;../../../../../../platform/drivers/edma/common;../../../../../../platform/drivers/enet;../../../../../../platform/drivers/enet/common;../../../../../../platform/drivers/flash;../../../../../../platform/drivers/flextimer;../../../../../../platform/drivers/flextimer/common;../../../../../../platform/drivers/gpio;../../../../../../platform/drivers/gpio/common;../../../../../../platform/drivers/i2c/i2c_master;../../../../../../platform/drivers/i2c/i2c_slave;../../../../../../platform/drivers/i2c/common;../../../../../../platform/drivers/lptmr;../../../../../../platform/drivers/lptmr/common;../../../../../../platform/drivers/lpuart;../../../../../../platform/drivers/lpuart/common;../../../../../../platform/drivers/mmcau;../../../../../../platform/drivers/mpu;../../../../../../platform/drivers/mpu/common;../../../../../../platform/drivers/pdb;../../../../../../platform/drivers/pdb/common;../../../../../../platform/drivers/pit;../../../../../../platform/drivers/pit/common;../../../../../../platform/drivers/rnga;../../../../../../platform/drivers/rnga/common;../../../../../../platform/drivers/rtc;../../../../../../platform/drivers/rtc/common;../../../../../../platform/drivers/sai;../../../../../../platform/drivers/sai/common;../../../../../../platform/drivers/sdcard;../../../../../../platform/drivers/sdhc;../../../../../../platform/drivers/sdhc/common;../../../../../../platform/drivers/soundcard;../../../../../../platform/drivers/spi;../../../../../../platform/drivers/spi/common;../../../../../../platform/drivers/uart;../../../../../../platform/drivers/uart/common;../../../../../../platform/drivers/wdog;../../../../../../platform/drivers/wdog/common;../../../../../../platform/utilities;../../../../../../rtos;../../../../../../platform/osa;../../../../../../platform/system/interrupt;../../../../../../platform/system/clock;../../../../../../platform/system/hwtimer
  asm define: CPU_MKL43Z256VLH4=1, FSL_RTOS_MQX=1, _DEBUG=1
  asm misc: --cpreproc
  asm include: ../../../../config/mcu/mkl43z256;../../../../config/board/frdmkl43z48m;../../../../mqx/source/psp/cortex_m/compiler/rv_uv4;../../../../mqx/source/psp/cortex_m;../../../../mqx/source/psp/cortex_m/core/M0;../../../../config/frdmkl43z48m;../../../../mqx/source/include;../../../../config/common
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: ..\..\..\lib\frdmkl43z48m.uv4\mqx\intflash.scf
  group Shell Source/mqx
    ../../../source/mqx/: sh_abort.c sh_kill.c sh_pause.c sh_tad.c
    ../../../source/include/: sh_prv.h shell.h
  group Shell Source/shell
    ../../../source/shell/: sh_cmdlist.c sh_exit.c sh_help.c sh_sh.c sh_util.c shell.c
    ../../../source/include/: sh_rtcs.h sh_enet.h
target nshell_frdmkl43z48m Release (ARM-ADS)
  device: MKL43Z256xxx4 Freescale Semiconductor
  pack: Keil.Kinetis_KLxx_DFP.1.2.2
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x6000) IRAM2(0x1FFFE000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(48000000) ELITTLE
  output: nshell.lib (library)
  AfterMake: ../../bat/nshell_frdmkl43z48m.bat ../../../.. ../../../../lib/frdmkl43z48m.uv4/release/nshell uv4
  c flags: Optim=4 OneElfS=1
  c define: CPU_MKL43Z256VLH4=1, FSL_RTOS_MQX=1, NDEBUG=1
  c misc: as above
  c include: as above
  asm define: CPU_MKL43Z256VLH4=1, FSL_RTOS_MQX=1, NDEBUG=1
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: ..\..\..\lib\frdmkl43z48m.uv4\mqx\intflash.scf
