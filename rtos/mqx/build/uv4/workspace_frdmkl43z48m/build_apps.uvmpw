<?xml version="1.0" encoding="UTF-8" standalone="no"?>
<ProjectWorkspace xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_mpw.xsd">
  <SchemaVersion>1.0</SchemaVersion>
  <Header>### uVision Project, (C) Keil Software</Header>
  <WorkspaceName>WorkSpace</WorkspaceName>
<project><PathAndName>..\..\..\mqx\examples\demo\build\uv4\demo_frdmkl43z48m\demo_frdmkl43z48m.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\event\build\uv4\event_frdmkl43z48m\event_frdmkl43z48m.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\hello\build\uv4\hello_frdmkl43z48m\hello_frdmkl43z48m.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\isr\build\uv4\isr_frdmkl43z48m\isr_frdmkl43z48m.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\klog\build\uv4\klog_frdmkl43z48m\klog_frdmkl43z48m.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\log\build\uv4\log_frdmkl43z48m\log_frdmkl43z48m.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\lwdemo\build\uv4\lwdemo_frdmkl43z48m\lwdemo_frdmkl43z48m.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\lwevent\build\uv4\lwevent_frdmkl43z48m\lwevent_frdmkl43z48m.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\lwlog\build\uv4\lwlog_frdmkl43z48m\lwlog_frdmkl43z48m.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\lwmsgq\build\uv4\lwmsgq_frdmkl43z48m\lwmsgq_frdmkl43z48m.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\lwsem\build\uv4\lwsem_frdmkl43z48m\lwsem_frdmkl43z48m.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\msg\build\uv4\msg_frdmkl43z48m\msg_frdmkl43z48m.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\mutex\build\uv4\mutex_frdmkl43z48m\mutex_frdmkl43z48m.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\nill\build\uv4\nill_frdmkl43z48m\nill_frdmkl43z48m.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\sem\build\uv4\sem_frdmkl43z48m\sem_frdmkl43z48m.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\taskat\build\uv4\taskat_frdmkl43z48m\taskat_frdmkl43z48m.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\taskq\build\uv4\taskq_frdmkl43z48m\taskq_frdmkl43z48m.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\test\build\uv4\test_frdmkl43z48m\test_frdmkl43z48m.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\timer\build\uv4\timer_frdmkl43z48m\timer_frdmkl43z48m.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\watchdog\build\uv4\watchdog_frdmkl43z48m\watchdog_frdmkl43z48m.uvproj</PathAndName><NodeIsActive>0</NodeIsActive></project></ProjectWorkspace>
