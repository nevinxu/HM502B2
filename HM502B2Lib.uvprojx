# Keil uVision project HM502B2Lib.uvprojx, settings and files
target HM502B2Lib (ARM-ADS)
  device: MKL17Z128xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.4.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x1FFFE000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: HM502B2Lib (library)
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: FSL_RTOS_FREE_RTOS,CPU_MKL17Z128VFT4,KEIL,
  c include: .\platform\system\clock;.\platform\system\clock\MKL17Z4;.\platform\system\interrupt;.\platform\system\power;.\platform\CMSIS\Include;.\platform\CMSIS\Include\device;.\platform\CMSIS\Include\device\MKL17Z4;.\platform\osa;.\platform\hal\adc;.\platform\hal\dma;.\platform\hal\dmamux;.\platform\hal\gpio;.\platform\hal\lptmr;.\platform\hal\lpuart;.\platform\hal\osc;.\platform\hal\pit;.\platform\hal\port;.\platform\hal\sim;.\platform\hal\smc;.\platform\hal\pmc;.\platform\hal\rcm;.\platform\hal\uart;.\platform\hal\mcglite;.\platform\drivers\adc;.\platform\drivers\adc\common;.\platform\drivers\dma;.\platform\drivers\dma\common;.\platform\drivers\gpio;.\platform\drivers\gpio\common;.\platform\drivers\lptmr;.\platform\drivers\lptmr\common;.\platform\drivers\lpuart;.\platform\drivers\lpuart\common;.\platform\drivers\pit;.\platform\drivers\pit\common;.\platform\drivers\tpm;.\platform\drivers\uart;.\platform\drivers\uart\common;.\platform\startup;.\platform\startup\MKL17Z4;.\rtos\FreeRTOS\config\KL43Z4\keil;.\rtos\FreeRTOS\include;.\rtos\FreeRTOS\port\keil;..\HM502B2Project
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  group system
    ./platform/system/clock/: fsl_clock_manager.c
    ./platform/system/clock/MKL17Z4/: fsl_clock_KL17Z4.c
    ./platform/system/interrupt/src/: fsl_interrupt_manager.c
    ./platform/system/power/src/: fsl_power_manager.c
  group osa
    ./platform/osa/src/: fsl_os_abstraction_free_rtos.c
  group hal
    ./platform/hal/adc/: fsl_adc_hal.c
    ./platform/hal/dma/: fsl_dma_hal.c
    ./platform/hal/dmamux/: fsl_dmamux_hal.c
    ./platform/hal/gpio/: fsl_gpio_hal.c
    ./platform/hal/lptmr/: fsl_lptmr_hal.c
    ./platform/hal/lpuart/: fsl_lpuart_hal.c
    ./platform/hal/mcglite/: fsl_mcglite_hal.c fsl_mcglite_hal_modes.c
    ./platform/hal/osc/: fsl_osc_hal.c
    ./platform/hal/pit/: fsl_pit_hal.c
    ./platform/hal/pmc/: fsl_pmc_hal.c
    ./platform/hal/port/: fsl_port_hal.c
    ./platform/hal/sim/: fsl_sim_hal.c
    ./platform/hal/sim/MKL17Z4/: fsl_sim_hal_KL17Z4.c
    ./platform/hal/smc/: fsl_smc_hal.c
    ./platform/hal/rcm/: fsl_rcm_hal.c
    ./platform/hal/uart/: fsl_uart_hal.c
  group drivers
    ./platform/drivers/adc/src/: fsl_adc_driver.c
    ./platform/drivers/adc/common/: fsl_adc_common.c
    ./platform/drivers/adc/: fsl_adc_irq.c
    ./platform/drivers/dma/src/: fsl_dma_driver.c
    ./platform/drivers/dma/common/: fsl_dma_common.c
    ./platform/drivers/dma/: fsl_dma_irq.c
    ./platform/drivers/gpio/src/: fsl_gpio_driver.c
    ./platform/drivers/gpio/common/: fsl_gpio_common.c
    ./platform/drivers/gpio/: fsl_gpio_irq.c
    ./platform/drivers/lptmr/src/: fsl_lptmr_driver.c
    ./platform/drivers/lptmr/common/: fsl_lptmr_common.c
    ./platform/drivers/lptmr/: fsl_lptmr_irq.c
    ./platform/drivers/lpuart/src/: fsl_lpuart_driver.c
    ./platform/drivers/lpuart/common/: fsl_lpuart_common.c
    ./platform/drivers/lpuart/: fsl_lpuart_irq.c
    ./platform/drivers/pit/src/: fsl_pit_driver.c fsl_pit_irq.c
    ./platform/drivers/pit/common/: fsl_pit_common.c
    ./platform/drivers/uart/src/: fsl_uart_driver.c
    ./platform/drivers/uart/common/: fsl_uart_common.c
    ./platform/drivers/uart/: fsl_uart_irq.c
