# Keil uVision project HM502B2.uvprojx, settings and files
target HM502B2 (ARM-ADS)
  device: MKL17Z128xxx4 Freescale Semiconductor
  pack: Keil.Kinetis_KLxx_DFP.1.4.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x1FFFE000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(48000000) ELITTLE
  output: HM502B2 +hex
  c flags: Optim=1 wLevel=2
  c define: DEBUG,CPU_MKL17Z128VFT4,KEIL, FREEDOM,FSL_RTOS_FREE_RTOS
  c misc: --library_interface=armcc  --library_type=standardlib --c99 --diag_suppress=1296,186
  c include: .\platform\CMSIS\Include;.\platform\CMSIS\Include\device;.\platform\system\clock;.\platform\system\clock\MKL17Z4;.\platform\startup\MKL17Z4;.\platform\hal\sim;.\platform\hal\sim\MKL17Z4;.\platform\hal\mcglite;.\platform\osa;.\platform\system\interrupt;.\platform\hal\lptmr;.\platform\drivers\lptmr;.\platform\drivers\lptmr\common;.\platform\hal\gpio;.\platform\drivers\gpio;.\platform\drivers\gpio\common;.\boards\frdmkl43z48m;.\platform\hal\port;.\platform\hal\gpio;.\platform\hal\adc;.\platform\drivers\adc;.\platform\drivers\adc\common;.\platform\drivers\lpuart;.\platform\drivers\lpuart\common;.\platform\hal\lpuart;.\platform\utilities;.\platform\drivers\uart;.\platform\drivers\uart\common;.\platform\hal\uart;.\rtos\FreeRTOS\config\KL43Z4\keil;.\rtos\FreeRTOS\include;.\rtos\FreeRTOS\port\keil;.\platform\hal\smc;.\platform\hal\pit;.\platform\drivers\pit;.\platform\drivers\pit\common;.\platform\hal\dma;.\platform\hal\dmamux;.\platform\drivers\dma;.\platform\drivers\dma\common;.\platform\hal\pit;.\platform\drivers\pit;.\platform\drivers\pit\common;.\App;.\platform\drivers\flash\C90TFS\drvsrc\include
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  scatter file: .\platform\linker\arm\MKL43Z4\MKL43Z256xxx4_flash.scf
  link misc: --remove
  group App
    ./App/: main.c EcgCapture.c EcgCapture.h BlueTooth.c BlueTooth.h ConnectPC.c ConnectPC.h pit_trigger.c user_cfg.h flash_demo.h
    ./platform/drivers/adc/: fsl_adc_irq.c
    ./platform/drivers/gpio/: fsl_gpio_irq.c
    ./platform/drivers/lpuart/: fsl_lpuart_irq.c
    ./platform/drivers/pit/src/: fsl_pit_irq.c
  group startup
    ./platform/startup/: startup.c startup.h
    ./platform/startup/MKL17Z4/: system_MKL17Z4.c system_MKL17Z4.h
    ./platform/startup/MKL17Z4/arm/: startup_MKL17Z4.s
  group platform
    ./platform/system/clock/MKL17Z4/: fsl_clock_KL17Z4.h
    ./platform/system/clock/: fsl_clock_manager.h
    ./platform/hal/sim/: fsl_sim_hal.h
    ./platform/hal/sim/MKL17Z4/: fsl_sim_hal_KL17Z4.h
    ./platform/hal/mcglite/: fsl_mcglite_hal.h fsl_mcglite_hal_modes.h
    ./platform/osa/: fsl_os_abstraction.h fsl_os_abstraction_free_rtos.h
    ./platform/system/interrupt/: fsl_interrupt_manager.h
    ./platform/hal/lptmr/: fsl_lptmr_hal.h
    ./platform/drivers/lptmr/: fsl_lptmr_driver.h
    ./platform/drivers/lptmr/common/: fsl_lptmr_common.h
    ./platform/hal/gpio/: fsl_gpio_hal.h
    ./platform/drivers/gpio/: fsl_gpio_driver.h
    ./platform/drivers/gpio/common/: fsl_gpio_common.h
    ./platform/hal/port/: fsl_port_hal.h
    ./platform/hal/lpuart/: fsl_lpuart_hal.h fsl_lpuart_hal.c
    ./platform/hal/adc/: fsl_adc_hal.h
    ./platform/drivers/adc/: fsl_adc_driver.h
    ./platform/drivers/adc/common/: fsl_adc_common.h
    ./platform/drivers/lpuart/: fsl_lpuart_driver.h
    ./platform/drivers/lpuart/common/: fsl_lpuart_common.h
    ./platform/hal/uart/: fsl_uart_hal.h
    ./platform/drivers/uart/: fsl_uart_driver.h
    ./platform/drivers/uart/common/: fsl_uart_common.h
    ./platform/hal/smc/: fsl_smc_hal.h fsl_smc_features.h
    ./platform/hal/pit/: fsl_pit_hal.h fsl_pit_features.h
    ./platform/drivers/pit/: fsl_pit_driver.h
    ./platform/drivers/pit/common/: fsl_pit_common.h
    ./platform/hal/dma/: fsl_dma_hal.h
    ./platform/hal/dmamux/: fsl_dmamux_hal.h
    ./platform/drivers/dma/: fsl_dma_driver.h
    ./platform/drivers/dma/common/: fsl_dma_common.h
    ./platform/drivers/lpuart/src/: fsl_lpuart_driver.c
    ./platform/drivers/pit/src/: fsl_pit_driver.c
    ./platform/drivers/adc/src/: fsl_adc_driver.c
  group board
    ./boards/frdmkl43z48m/: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h hardware_init.c board.h
  group utilities
    ./platform/utilities/src/: fsl_misc_utilities.c
    ./platform/utilities/: fsl_misc_utilities.h
  group freertos
    ./rtos/FreeRTOS/port/keil/: portmacro.h portTicks.h
    ./rtos/FreeRTOS/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    ./rtos/FreeRTOS/config/KL43Z4/keil/: FreeRTOSConfig.h
  group lib
    ./Objects/: Freertoslib.lib HM502B2Lib.lib
  group Flash
    ./platform/drivers/flash/C90TFS/drvsrc/source/: CopyToRam.c DEFlashPartition.c DFlashGetProtection.c DFlashSetProtection.c EEEWrite.c EERAMGetProtection.c EERAMSetProtection.c FlashCheckSum.c FlashCommandSequence.c FlashEraseAllBlock.c FlashEraseBlock.c FlashEraseResume.c FlashEraseSector.c FlashEraseSuspend.c FlashGetSecurityState.c FlashInit.c FlashProgram.c FlashProgramCheck.c FlashProgramOnce.c FlashProgramSection.c FlashReadOnce.c FlashReadResource.c FlashSecurityBypass.c FlashVerifyAllBlock.c FlashVerifyBlock.c FlashVerifySection.c PFlashGetProtection.c PFlashSetProtection.c PFlashSwap.c PFlashSwapCtl.c SetEEEEnable.c
